# Keil uVision project Project_F330_interrupts.uvproj, settings and files
target F330 (MCS-51)
  device: C8051F330 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: Project_F330_interrupts
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: F330_main.c F330_sub.c config.c
